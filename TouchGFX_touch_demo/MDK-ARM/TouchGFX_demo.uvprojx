# Keil uVision project TouchGFX_demo.uvprojx, settings and files
target TouchGFX_demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: TouchGFX_demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Inc;../Src;../TouchGFX/generated/fonts/include;../TouchGFX/generated/texts/include;../TouchGFX/generated/images/include;../TouchGFX/generated/gui_generated/include;../TouchGFX/gui/include;../middlewares/st/touchgfx/touchgfx/framework/include;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/BSP/Components/exc7200;../Drivers/BSP/Components/stmpe811;../Drivers/BSP/Components/ts3510;../Drivers/BSP/Components/ampire480272;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/BSP/Components/Common;../Drivers/CMSIS/Include;../middlewares/st/touchgfx/touchgfx/framework/include;..\application\touch;..\application
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User
    ../Src/: main.cpp gpio.c crc.c freertos.c BoardConfiguration.cpp touchgfx_gpio.cpp STM32F4DMA.cpp STM32F4HAL.cpp STM32F4TouchController.cpp STM32F4Instrumentation.cpp HW_Init.cpp sys.c stm32f4xx_hal_timebase_tim.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma2d.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_crc.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/TouchGFX
    ../middlewares/st/touchgfx/touchgfx/lib/core/cortex_m4f/Keil/: touchgfx_core.lib
    ../Middlewares/ST/TouchGFX/touchgfx/lib/core/cortex_m4f/Keil/: touchgfx_core.lib
    ../Middlewares/ST/TouchGFX/touchgfx/os/: OSWrappers.cpp
  group Application/User/TouchGFX/gui
    ../touchgfx/gui/src/common/: frontendapplication.cpp
    ../touchgfx/gui/src/model/: model.cpp
    ../touchgfx/gui/src/screen1_screen/: screen1presenter.cpp screen1view.cpp
  group Application/User/TouchGFX/generated
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp fontcache.cpp generatedfont.cpp kerning_verdana_10_4bpp.cpp kerning_verdana_20_4bpp.cpp kerning_verdana_40_4bpp.cpp table_verdana_10_4bpp.cpp table_verdana_20_4bpp.cpp table_verdana_40_4bpp.cpp
    ../touchgfx/generated/images/src/: bitmapdatabase.cpp
    ../touchgfx/generated/images/src/__designer/: blue_backgrounds_main_bg_800x480px.cpp blue_buttons_round_edge_small.cpp blue_buttons_round_edge_small_pressed.cpp blue_progressindicators_bg_medium_circle_indicator_bg_full.cpp blue_progressindicators_fill_medium_circle_indicator_fill_full.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/gui_generated/src/screen1_screen/: screen1viewbase.cpp
    ../touchgfx/generated/texts/src/: texts.cpp typedtextdatabase.cpp
  group touch
    ../application/touch/: GT811.c TS_I2C.c
    ../application/: gt9xx.c bsp_i2c_touch.c bsp_debug_usart.c
software components: CMSIS:CORE 4.3.0
